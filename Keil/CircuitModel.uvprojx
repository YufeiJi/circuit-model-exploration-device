# Keil uVision project CircuitModel.uvprojx, settings and files
target CircuitModel (6160000::V6.16::ARMCLANG)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x8000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: CircuitModel +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F407xx
  c misc: -Wno-padded
  c include: .\Core;.\BSP;.\App;.\Drivers\CMSIS\Device\Include;.\Drivers\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\CircuitModel.sct
  group User
    ./Core/: main.c system_stm32f4xx.c
  group BSP
    ./BSP/: bsp.c
  group App
    ./App/: app_dds.c app_meas.c app_known.c app_ident.c
  group Drivers
    ./Drivers/CMSIS/Device/Source/: startup_stm32f407xx.s
